Commit message: input yours message

File: install/fishbot_cartographer/share/fishbot_cartographer/urdf/fishot_2d.urdf (robot description, URDF)
Before this commit: robot cartographer_backpack_3d, 2 links, 1 joints
Joints:
- joint laser_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0.1 rpy=0 0 0
